# Keil uVision project template.uvprojx, settings and files
target Target 1 (6150000::V6.15::ARMCLANG)
  device: GD32E230C8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=7 OneElfS=1
  c define: GD32E230
  c include: ..\Libraries\Include;..\User;..\CMSIS;..\Hardware\DEFINE;..\Hardware\BSP;..\Hardware\MULTITASK;..\Hardware\VECTOR;..\Hardware\LED;..\Hardware\QUEUE;..\Hardware\PCMODEL;..\Hardware\USART;..\Hardware\MDU_COMM;..\Hardware\TIMER;..\Hardware\MOTOR;..\Hardware\ADC;..\Hardware\EXTI;..\Hardware\WATERLEVEL;..\Hardware\TM1650;..\Hardware\KEY;..\Hardware\MSGQUEUE;..\Hardware\GD32FLASH;..\Hardware\RFID_COMM;..\Hardware\VALVE
  asm define: GD32E230
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ../User/: gd32e23x_it.c main.c systick.c
    ./: 实验说明.txt
  group CMSIS
    ../CMSIS/: system_gd32e23x.c
  group Startup
    ../Startup/: startup_gd32e23x.s
  group Library
    ../Libraries/Source/: gd32e23x_adc.c gd32e23x_cmp.c gd32e23x_crc.c gd32e23x_dbg.c gd32e23x_dma.c gd32e23x_exti.c gd32e23x_fmc.c gd32e23x_fwdgt.c gd32e23x_gpio.c gd32e23x_i2c.c gd32e23x_misc.c gd32e23x_pmu.c gd32e23x_rcu.c gd32e23x_rtc.c gd32e23x_spi.c gd32e23x_syscfg.c gd32e23x_timer.c gd32e23x_usart.c gd32e23x_wwdgt.c
  group Hardware
    ../Hardware/DEFINE/: define.c
    ../Hardware/BSP/: bsp.c
    ../Hardware/MULTITASK/: multitask.c
    ../Hardware/VECTOR/: vector.c
    ../Hardware/LED/: led.c
    ../Hardware/QUEUE/: queue.c
    ../Hardware/PCMODEL/: pcmodel.c
    ../Hardware/USART/: usart0.c usart1.c
    ../Hardware/MDU_COMM/: mdu_data.c
    ../Hardware/TIMER/: timer2.c timer14.c timer15.c
    ../Hardware/MOTOR/: motor.c
    ../Hardware/ADC/: adc.c
    ../Hardware/EXTI/: exti.c
    ../Hardware/WATERLEVEL/: waterlevel.c
    ../Hardware/TM1650/: tm1650.c
    ../Hardware/KEY/: key.c
    ../Hardware/MSGQUEUE/: msgqueue.c
    ../Hardware/GD32FLASH/: gd32flash.c
    ../Hardware/RFID_COMM/: rfid_data.c
    ../Hardware/VALVE/: valve.c
